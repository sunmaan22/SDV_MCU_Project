<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SDV_IVI_H735.ewp</path>
  </project>
  <batchBuild />
</workspace>
